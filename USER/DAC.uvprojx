# Keil uVision project DAC.uvprojx, settings and files
target DAC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: DAC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\DAC;..\FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\BUTTON_APP;..\HARDWARE\DSP_LIB;..\HARDWARE\DSP_LIB\Include;..\HARDWARE\FFT;..\HARDWARE\SWEEP
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/BUTTON_APP/: button_app.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/FFT/: fft.c
    ../HARDWARE/SWEEP/: sweep.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_sai.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_ltdc.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_hash_sha1.c stm32f4xx_hash_md5.c stm32f4xx_hash.c stm32f4xx_flash_ramfunc.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_dma2d.c stm32f4xx_dma.c stm32f4xx_dcmi.c stm32f4xx_dbgmcu.c stm32f4xx_cryp_tdes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_aes.c stm32f4xx_cryp.c stm32f4xx_crc.c stm32f4xx_can.c
  group README
    ../: readme.txt
  group DSP_LIB
    ../HARDWARE/DSP_LIB/: arm_cortexM4lf_math.lib
